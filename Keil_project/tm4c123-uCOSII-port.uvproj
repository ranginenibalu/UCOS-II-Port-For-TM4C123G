# Keil uVision project tm4c123-uCOSII-port.uvproj, settings and files
target TI launchpad (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: tm4c123-uCOSII-port +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\Application;..\Board_Support_Package;..\uC-CPU_files;..\uC-Library_files;..\uCOS-II_files\Ports;..\uCOS-II_files\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ../Application/: app.c app_cfg.h app_hooks.c bsp_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h
  group board_support_package
    ../Board_Support_Package/: bsp.c bsp.h bsp_int.c bsp_int.h bsp_led.c bsp_led.h bsp_sys.c bsp_sys.h cpu_bsp.c startup_TM4C123.s bsp_sw.c bsp_sw.h bsp_uart.c bsp_uart.h bsp_pir_sensor.h bsp_pir_sensor.c
  group ucosii_library
    ../uC-Library_files/: lib_ascii.c lib_ascii.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h lib_def.h
  group ucosii_cpu
    ../uC-CPU_files/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group ucosii_source
    ../uCOS-II_files/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group ucosii_port
    ../uCOS-II_files/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
